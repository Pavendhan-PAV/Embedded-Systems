<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\Lab-6\6.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\main.ewp</path>
    </project>
    <batchBuild />
</workspace>
